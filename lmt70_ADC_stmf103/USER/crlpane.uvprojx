# Keil uVision project crlpane.uvprojx, settings and files
target Program (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: crlpane +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\HARDWARE\IIC;..\HARDWARE\MCP3421;..\APP\HAL;..\APP\FML;..\APP\DRL;..\APP\BLL;..\APP\APP\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c misc.c stm32f10x_usart.c
  group SYS
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group APP/App
    ../APP/APP/src/: my_app.c
  group APP/Drl
    ../APP/DRL/: lmt70.c mcp3421.c
  group APP/Hal
    ../APP/HAL/: port_delay.c port_iic.c port_debug.c
