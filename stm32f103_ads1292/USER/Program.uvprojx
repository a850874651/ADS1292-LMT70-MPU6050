# Keil uVision project Program.uvprojx, settings and files
target Program (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Program
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\APP\APP\inc;..\APP\BLL;..\APP\DRL;..\APP\FML;..\APP\HAL;..\APP\EXTI;..\APP\GBK_LibDrive;..\APP\KEY;..\APP\LCD;..\APP\TIMER;..\APP\TOUCH;..\APP\LED;..\APP\WDG;..\SYSTEM\delay;..\SYSTEM\usart2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_fsmc.c
  group SYS
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart2/: usart2.c
  group APP/App
    ../APP/APP/src/: my_app.c
  group APP/Drl
    ../APP/DRL/: ads1292r.c
  group APP/Hal
    ../APP/HAL/: port_spi.c port_gpio.c port_delay.c port_debug.c
  group APP/HARDWARE
    ../APP/GBK_LibDrive/: GBK_LibDrive.c
    ../APP/KEY/: key.c
    ../APP/LCD/: Dis_Picture.c FONT.c lcd.c Picture.c Text.c
    ../APP/LED/: led.c
